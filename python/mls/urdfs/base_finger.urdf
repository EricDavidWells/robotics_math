Commit message: all working with ur5

File: python/mls/urdfs/base_finger.urdf (robot description, URDF)
Before this commit: robot base_finger, 6 links, 5 joints
Joints:
- removed joint tip
